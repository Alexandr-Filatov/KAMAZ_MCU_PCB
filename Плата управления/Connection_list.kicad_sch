File: Плата управления/Connection_list.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Изменения: добавил папку с отчетностью
Other:
- note removed: "Узел соединительный"
